FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
                  file://0001-mali_linux_trace-fix-typo-in-stringify-macro.patch \
"
