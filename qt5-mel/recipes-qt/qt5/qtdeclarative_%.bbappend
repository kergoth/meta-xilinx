# Add mesa driver and qt plugins required for running qtdeclarative examples
RDEPENDS_${PN} += "mesa-driver-swrast qtdeclarative-qmlplugins"
