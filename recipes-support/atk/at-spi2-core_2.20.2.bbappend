FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-at-spi-bus-launcher-session-management-fixes.patch"

