FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_zc702 = " file://zc702-dts-add-can0.patch"
