FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_zedboard = " file://ptp.cfg"
