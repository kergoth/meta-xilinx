FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_zc702 = " file://zc702-xilinx_can-add-support-to-drive-transceiver-enable-pin.patch"
