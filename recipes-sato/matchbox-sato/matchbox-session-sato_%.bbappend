# Append path to include MEL custom session
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
