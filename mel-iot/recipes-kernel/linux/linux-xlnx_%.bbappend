FILESEXTRAPATHS_prepend := "${THISDIR}/files:}:"

SRC_URI_append = " \
    file://6lowpan.cfg \
"
