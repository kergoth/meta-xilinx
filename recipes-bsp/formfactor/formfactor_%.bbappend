# Append path to override formfactor configs with MEL custom config and matchconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

